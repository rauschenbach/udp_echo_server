# IAR project udp_echo_server.ewp, settings and files
configuration Discover-More (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; _SERIAL_DEBUG; USE_DHCP; NO_DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..; ..\eth; ..\sys; ..\periph; ..\tasks; ..\Library\CMSIS\Device\ST\STM32F4xx\Include; ..\Library\STM32F4xx_StdPeriph_Driver\inc; ..\Library\STM32F4-Discovery; ..\Library\lwip\src\include\netif; ..\Library\lwip\src\include\lwip; ..\Library\lwip\src\include\ipv4; ..\Library\lwip\src\include; ..\Library\lwip\port\; ..\library\FreeRTOS\Source\include; ..\library\FreeRTOS\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: udp_echo_server.srec
  ILINK.IlinkOutputFile: udp_echo_server.out
  ILINK.IlinkIcfFile: udp_echo_server.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c
  group library/CMSIS
    ../library/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
    ../library/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group library/FreeRTOS
    ../library/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c
  group library/FreeRTOS/portable
    ../library/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../library/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group library/LWIP
    ../library/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../library/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../library/lwip/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../library/lwip/port/: enc28j60.c sys_arch.c
    ../library/lwip/src/netif/: etharp.c loopif.c slipif.c
  group library/STM32F4-Discovery
    ../library/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_lcd.c
  group library/STM32F4xx_StdPeriph_Driver
    ../library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group periph
    ../periph/: serial_debug.c spi.c
  group sys
    ../sys/: stm32f4xx_it.c
  group tasks
    ../tasks/: netconf.c udpecho.c
  group Utils
    ../utils/: userfunc.c
